SUMMARY = "Leopard Safe image"
LICENSE = "CLOSED"

inherit base-leopard-image

IMAGE_FSTYPES:append = " cpio.lzma"