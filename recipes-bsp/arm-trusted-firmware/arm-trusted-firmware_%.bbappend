# If debug output is needed change 0 -> 1.
DEBUG_ATF_DEFAULT = "0"